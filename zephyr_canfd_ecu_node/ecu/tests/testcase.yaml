## zephyr_canfd_ecu_node/ecu/tests/testcase.yaml
```yaml
common:
  tags: unit_testing
tests:
  ecu.unit:
    platform_allow: unit_testing
```
